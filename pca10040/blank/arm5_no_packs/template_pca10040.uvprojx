# Keil uVision project template_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD MBEDTLS_CONFIG_FILE=<nrf_crypto_mbedtls_config.h> NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1 MPU6050 USE_DMP EMPL
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\cifra_AES128-EAX;..\..\..\..\..\..\external\fnmatch;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\external\protothreads;..\..\..\..\..\..\external\protothreads\pt-1.4;..\..\..\..\..\..\external\thedotfactory_fonts;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config;..\..\..\eMPL;..\..\..\..\..\..\components\libraries\serial
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_CRYPTO_MAX_INSTANCE_COUNT=1 SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_CRYPTO_MAX_INSTANCE_COUNT=1,-DSWI_DISABLE0,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\cli;..\..\..\..\..\..\components\libraries\cli\uart;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\experimental_task_manager;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gfx;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hardfault\nrf52;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\mpu;..\..\..\..\..\..\components\libraries\mutex;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\pwr_mgmt;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sdcard;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\..\components\libraries\spi_mngr;..\..\..\..\..\..\components\libraries\stack_guard;..\..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi_mngr;..\..\..\..\..\..\components\libraries\twi_sensor;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\cifra_AES128-EAX;..\..\..\..\..\..\external\fnmatch;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\mbedtls\include;..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\external\nrf_oberon;..\..\..\..\..\..\external\nrf_oberon\include;..\..\..\..\..\..\external\nrf_tls\mbedtls\nrf_crypto\config;..\..\..\..\..\..\external\protothreads;..\..\..\..\..\..\external\protothreads\pt-1.4;..\..\..\..\..\..\external\thedotfactory_fonts;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c board.c
    ../config/: sdk_config.h
  group nRF_Core
    ../../../../../../components/libraries/mpu/: nrf_mpu.c
    ../../../../../../components/libraries/stack_guard/: nrf_stack_guard.c
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
  group nRF_Crypto backend Oberon
    ../../../../../../components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_Crypto backend cifra
    ../../../../../../components/libraries/crypto/backend/cifra/: cifra_backend_aes_aead.c
  group nRF_Crypto backend mbed TLS
    ../../../../../../components/libraries/crypto/backend/mbedtls/: mbedtls_backend_aes.c mbedtls_backend_aes_aead.c mbedtls_backend_ecc.c mbedtls_backend_ecdh.c mbedtls_backend_ecdsa.c mbedtls_backend_hash.c mbedtls_backend_hmac.c mbedtls_backend_init.c
  group nRF_Crypto backend nRF HW
    ../../../../../../components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
  group nRF_Crypto backend uECC
    ../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_rng.c nrf_drv_spi.c nrf_drv_spis.c nrf_drv_swi.c nrf_drv_twi.c nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_comp.c nrfx_gpiote.c nrfx_i2s.c nrfx_lpcomp.c nrfx_pdm.c nrfx_power.c nrfx_power_clock.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_swi.c nrfx_timer.c nrfx_twi.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_wdt.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Drivers_External
    ../../../../../../components/libraries/twi_sensor/: nrf_twi_sensor.c
  group nRF_External
    ../../../../../../external/thedotfactory_fonts/: orkney24pts.c orkney8pts.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/pwm/: app_pwm.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/sdcard/: app_sdcard.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../external/cifra_AES128-EAX/: blockwise.c cifra_cmac.c cifra_eax_aes.c eax.c gf128.c modes.c
    ../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/fds/: fds.c
    ../../../../../../external/fnmatch/: fnmatch.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/hci/: hci_mem_pool.c hci_slip.c hci_transport.c
    ../../../../../../components/libraries/led_softblink/: led_softblink.c
    ../../../../../../components/libraries/low_power_pwm/: low_power_pwm.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../components/libraries/cli/uart/: nrf_cli_uart.c
    ../../../../../../components/libraries/csense/: nrf_csense.c
    ../../../../../../components/libraries/csense_drv/: nrf_drv_csense.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../../../../../../components/libraries/gfx/: nrf_gfx.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/spi_mngr/: nrf_spi_mngr.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/twi_mngr/: nrf_twi_mngr.c
    ../../../../../../components/libraries/slip/: slip.c
    ../../../../../../components/libraries/experimental_task_manager/: task_manager.c task_manager_core_keil.s
    ../../../../../../components/libraries/serial/: nrf_serial.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_Oberon_Crypto
    ../../../../../../external/nrf_oberon/lib/nrf52/: oberon_short_wchar_2.0.5.lib
  group nRF_TLS
    ../../../../../../external/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_ticket.c ssl_tls.c threading.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    ../../../../../../external/nrf_tls/mbedtls/replacements/: asn1write.c ssl_srv.c
  group nRF_micro-ecc
    ../../../../../../external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nrf_cc310
    ../../../../../../external/nrf_cc310/lib/: nrf_cc310_keil_0.9.10.lib
  group eMPL
    ../../../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c libmpllib.lib data_builder.c eMPL_outputs.c hal_outputs.c log_nrf52.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.17.0
